# The head unit's name on the network. ConnMan sends it in its DHCP requests,
# so routers list the board by it rather than by the machine name.
hostname = "TrailCurrentGodwit"
