SUMMARY = "Spotify Connect player"
DESCRIPTION = "go-librespot plays Spotify on the head unit for the HMI's \
Spotify source. The HMI runs it with its own settings and drives it through \
its API on 127.0.0.1. Needs Spotify Premium and an internet connection; it \
is an optional extra, never part of the head unit's core functions."
HOMEPAGE = "https://github.com/devgianlu/go-librespot"
LICENSE = "GPL-3.0-only"
LIC_FILES_CHKSUM = "file://src/${GO_IMPORT}/LICENSE;md5=02f117cb774083d3ae16e938a01319c7"

SRC_URI = "git://${GO_IMPORT};protocol=https;nobranch=1;destsuffix=${GO_SRCURI_DESTSUFFIX}"
SRCREV = "90a4fdaf0314269e3fa25698a5f4270c026d2c03"
GO_IMPORT = "github.com/devgianlu/go-librespot"
GO_INSTALL = "${GO_IMPORT}/cmd/daemon"
GO_EXTRA_LDFLAGS = "-X ${GO_IMPORT}.version=${PV}"

# The Go modules it builds with, and their licenses, generated by
#   bitbake -c update_modules go-librespot
# writes these two files beside this recipe. Run it once before the first
# build, and again after changing the version. Where it cannot name a
# module's license it writes spdx=Unknown; set the right SPDX id on that line
# by hand and the task keeps it, as it matches licenses by checksum.
include ${BPN}-go-mods.inc
include ${BPN}-licenses.inc
# AGL's demo layer lists a licenses folder it does not have, and the license
# finder update_modules uses fails on a missing folder; keep the ones there
LICENSE_PATH := "${@' '.join(p for p in (d.getVar('LICENSE_PATH') or '').split() if os.path.isdir(p))}"

# Ogg Vorbis, FLAC and MP3 decoding and ALSA output, through cgo. ALSA's
# default device is PipeWire (pipewire-alsa), where the sound takes the
# multimedia role like the HMI's own.
DEPENDS = "alsa-lib libogg libvorbis flac mpg123"
export CGO_ENABLED = "1"

inherit go-mod go-mod-update-modules pkgconfig

do_install:append() {
    # The daemon's main package builds as "daemon"; give it its own name
    mv ${D}${bindir}/daemon ${D}${bindir}/go-librespot
}

RDEPENDS:${PN} = "pipewire-alsa"
