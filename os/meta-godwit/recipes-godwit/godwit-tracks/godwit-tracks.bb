SUMMARY = "Race tracks of North America for the Godwit Track app"
DESCRIPTION = "Road courses, ovals and drag strips from OpenStreetMap: each \
track's outline, start/finish line and arrival geofence, and an index for \
searching them. Generated by hmi/tools/tracks; see files/tracks/README.md."
# The track geometry is OpenStreetMap data
LICENSE = "ODbL-1.0"
LIC_FILES_CHKSUM = "file://${UNPACKDIR}/tracks/README.md;beginline=6;endline=10;md5=45754ba1fbc20a3b429d838c71be8b67"

SRC_URI = "file://tracks"
S = "${UNPACKDIR}"

inherit allarch

do_configure[noexec] = "1"
do_compile[noexec] = "1"

do_install() {
    install -d ${D}${datadir}/godwit/tracks/tracks
    install -m 0644 ${UNPACKDIR}/tracks/index.json ${UNPACKDIR}/tracks/README.md ${D}${datadir}/godwit/tracks/
    install -m 0644 ${UNPACKDIR}/tracks/tracks/*.json ${D}${datadir}/godwit/tracks/tracks/
}

FILES:${PN} = "${datadir}/godwit/tracks"
